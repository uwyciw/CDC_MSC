<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADIS16227_LOG.ewp</path>
  </project>
  <batchBuild />
</workspace>
